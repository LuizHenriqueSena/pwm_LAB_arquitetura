# IAR project myProject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; CPU_MKL25Z128VLK4; FRDM_KL25Z; FREEDOM
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\../platform/osa/inc; ..\..\..\..\../platform/utilities/inc; ..\..\..\..\../platform/CMSIS/Include; ..\..\..\..\../platform/devices; ..\..\..\..\../platform/devices/MKL25Z4/include; ..\..\..\..\../platform/devices/MKL25Z4/startup; ..\..\..\..\../platform/hal/inc; ..\..\..\..\../platform/drivers/inc; ..\..\..\..\../platform/system/inc; ../../..; ../board; ..\..\..\..\../platform/drivers/src/adc16; ..\..\..\..\../platform/drivers/src/cmp; ..\..\..\..\../platform/drivers/src/dac; ..\..\..\..\../platform/drivers/src/dma; ..\..\..\..\../platform/drivers/src/gpio; ..\..\..\..\../platform/drivers/src/i2c; ..\..\..\..\../platform/drivers/src/lpsci; ..\..\..\..\../platform/drivers/src/lptmr; ..\..\..\..\../platform/drivers/src/pit; ..\..\..\..\../platform/drivers/src/rtc; ..\..\..\..\../platform/drivers/src/spi; ..\..\..\..\../platform/drivers/src/tpm; ..\..\..\..\../platform/drivers/src/tsi; ..\..\..\..\../platform/drivers/src/uart; ..\..\..\..\../platform/drivers/src/cop
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: myProject.out
  ILINK.IlinkIcfFile: ..\..\..\..\../platform/devices/MKL25Z4/linker/iar/MKL25Z128xxx4_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\../lib/ksdk_platform_lib/iar/KL25Z4/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MKL25Z128VLK4; FRDM_KL25Z; FREEDOM
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../platform/devices/MKL25Z4/startup/iar/: startup_MKL25Z4.s
    ../../../../../platform/devices/MKL25Z4/startup/: system_MKL25Z4.c system_MKL25Z4.h
    ../../../../../platform/devices/: startup.c startup.h
  group sources
    ../: main.c main.h
  group board
    ../board/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
    ../: hardware_init.c
  group utilities
    ../../../../../platform/utilities/src/: fsl_debug_console.c print_scan.c
    ../../../../../platform/utilities/inc/: fsl_debug_console.h print_scan.h
