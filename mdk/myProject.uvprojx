# Keil uVision project myProject.uvprojx, settings and files
target myProject Debug (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  output: myProject.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, state, name
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186,66,111,223  --library_interface=armcc
  c include: ../../..; ../../../../../platform/osa/inc; ../../../../../platform/utilities/inc; ../../../../../platform/CMSIS/Include; ../../../../../platform/devices; ../../../../../platform/devices/MKL25Z4/include; ../../../../../platform/devices/MKL25Z4/startup; ../../../../../platform/hal/inc; ../../../../../platform/drivers/inc; ../../../../../platform/system/inc; ../../; ../board; ../../../../../platform/drivers/src/adc16; ../../../../../platform/drivers/src/cmp; ../../../../../platform/drivers/src/dac; ../../../../../platform/drivers/src/dma; ../../../../../platform/drivers/src/gpio; ../../../../../platform/drivers/src/i2c; ../../../../../platform/drivers/src/lpsci; ../../../../../platform/drivers/src/lptmr; ../../../../../platform/drivers/src/pit; ../../../../../platform/drivers/src/rtc; ../../../../../platform/drivers/src/spi; ../../../../../platform/drivers/src/tpm; ../../../../../platform/drivers/src/tsi; ../../../../../platform/drivers/src/uart; ../../../../../platform/drivers/src/cop
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x00000000 size 0x20000
  memory RVCT9: RAM 0x1FFFF000 size 0x00004000
  scatter file: ../../../../../platform/devices/MKL25Z4/linker/arm/MKL25Z128xxx4_flash.scf
  link misc: ../../../../../lib/ksdk_platform_lib/mdk/KL25Z4/debug/libksdk_platform.lib
  group startup
    ../../../../../platform/devices/MKL25Z4/startup/arm/: startup_MKL25Z4.s
    ../../../../../platform/devices/MKL25Z4/startup/: system_MKL25Z4.c system_MKL25Z4.h
    ../../../../../platform/devices/: startup.c startup.h
  group sources
    ../: main.c main.h
  group board
    ../board/: gpio_pins.c gpio_pins.h pin_mux.c pin_mux.h board.c board.h
    ../: hardware_init.c
  group utilities
    ../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.c print_scan.h
    ../../../../../platform/utilities/inc/: fsl_debug_console.h
target myProject Release (ARM-ADS)
  device: MKL25Z128xxx4 Freescale
  output: myProject.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: state, name
  c misc: --library_type=standardlib --c99 --diag_suppress=1296,186  --library_interface=armcc
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x00000000 size 0x20000
  memory RVCT9: RAM 0x1FFFF000 size 0x00004000
  scatter file: as above
  link misc: as above
